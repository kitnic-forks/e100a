# Repository kitnic-forks/e100a

File README.md:

E100A All-Discrete Power Supply Kit
==================================

Work in progress. This will be a semi-educational kit for a bench power
supply made from all discrete components.

## KiCad design Proj-Main/psu.kicad_pcb

Parts:
C1, C3, C11, C12: 1n
C2: 1000u 63V
C4, C5, C9: 47u 63V
C6, C7, C8: 4u7
C10: 1nF 1kV
D1, D2, D3, D4, D5, D6, D7, D8, D11, D12: S1D
D9, D10: MMBD4148
DS1: HOT; PartNo PM5RD
DS2: LIM; PartNo PM5RD
DS3: POWER; PartNo PM5RD
DZ1: 6v2; PartNo BZX84-B6V2
DZ2: 3v0
DZ3: SMCJ30A-E3/9AT
J1: T1A; PartNo 60824-1
J2: T1B; PartNo 60824-1
J3: T1C; PartNo 60824-1
J4: OUT+; PartNo 60824-1
J5: SENSE
J6: METER
J7: OUT-; PartNo 60824-1
Q1, Q4, Q13, Q15, Q17: BC856
Q2, Q9, Q11, Q16, Q18, Q20: MMBT3904
Q3, Q22: PZT2222A
Q5, Q8, Q10, Q12, Q23: PMP4201Y
Q6, Q7: MMBT3906
Q14, Q19, Q24: MMBT2907A
Q21: TIP105
R1, R3, R4, R6, R16, R17, R34, R36, R39, R46: 22k
R2, R13, R14, R38: 33
R5: 30k
R7, R9, R24, R30, R32, R33, R35, R43, R45, R56, R57: 1k
R8, R10, R25, R26, R27, R28, R31, R41, R44: 10k
R11, R12: 470
R15, R40: 100k
R18, R19: 22k 0.5%
R20, R42: 2k
R22: NTC; PartNo NTCLE100E3334JB0; MouserPN 594-2381-640-63104
R23, R29: 100
R37, R55: 10k QW
R47: * 1/2W
R48: 1Meg
R49, R50: * 0.5%
R51, R54: *
R52, R53: 270
RV1, RV2, RV4: 10k
RV3: 1k
RV5, RV6: *
TP1, TP2, TP3, TP4: GND

Connections:
+2: C2.1, D3.1, D4.1, D5.2, D7.1, Q1.2, Q4.2, Q10.3, Q10.6, Q19.2, Q23.3, R7.1, R9.1, R23.1, R29.1, R32.1, R34.1, R42.1, R45.1, R55.1
-12: C3.2, C5.2, Q3.2, Q3.4, Q11.2, Q16.2, R3.1, R4.2, R6.2, R8.2, R13.2, R14.2, R16.2, R17.2, R22.2, R27.2, R28.2, R44.2, RV4.2, RV4.3
/FB+: Q12.2, Q24.3, R18.2, R49.2
/FB-: D10.3, Q12.1, Q16.3, R19.2, R50.2, R56.1
/GUARD: D10.1, Q9.3, Q12.4, Q12.5
/OUT+: C9.1, D11.1, DZ3.K, J4.1, J6.2, Q23.2, R46.1, R47.2, R52.1, R54.1
/OUT-: C9.2, D12.1, DZ3.A, J6.3, J7.1, Q20.2, Q21.3, R38.1, R46.2, R53.1
CGND: C10.2, R48.2
GND: C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, D7.2, D8.1, D9.1, Q10.1, Q14.2, Q22.2, Q22.4, R5.1, R15.1, R20.1, R40.1, R47.1, R48.1, R51.1, RV1.1, RV3.1, TP1.1, TP2.1, TP3.1, TP4.1
unnamed: C1.1, Q1.3, R1.1
unnamed: C1.2, Q2.3, Q3.1, R1.2
unnamed: C3.1, Q5.1, R5.2, R6.1
unnamed: C6.2, Q5.2, R10.2
unnamed: C7.2, Q10.2, R15.2, RV1.2
unnamed: C8.2, Q11.3, R20.2, R22.1, R25.2
unnamed: C11.1, R56.2
unnamed: C11.2, Q18.3, Q21.1, R34.2, R36.2
unnamed: C12.1, R57.2
unnamed: C12.2, Q23.1, R40.2, RV3.2
unnamed: D1.1, D3.2, J1.1
unnamed: D2.1, D4.2, J3.1
unnamed: D5.1, D6.2
unnamed: D6.1, D8.2
unnamed: D9.3, DZ1.3
unnamed: D11.2, J5.1, R49.1, R52.2
unnamed: D12.2, J5.2, R50.1, R53.2
unnamed: DS1.A, DZ2.3, Q14.3
unnamed: DS1.K, DZ2.1, R26.1, R27.1, R28.1, R31.2
unnamed: DS2.A, R37.2
unnamed: DS3.A, R55.2
unnamed: DZ1.1, R10.1, R11.1, RV2.2, RV2.3
unnamed: J6.1, RV5.1, RV5.2
unnamed: J6.4, RV6.1, RV6.2
unnamed: Q1.1, Q4.3, R4.1
unnamed: Q2.1, Q3.3, R2.1
unnamed: Q4.1, Q5.3, Q7.3
unnamed: Q5.4, Q5.5, R8.1
unnamed: Q5.6, Q6.1, Q6.3, Q7.1
unnamed: Q6.2, R7.2
unnamed: Q7.2, R9.2
unnamed: Q8.1, Q8.2, Q8.6, R12.2
unnamed: Q8.3, Q9.2
unnamed: Q8.4, R14.1
unnamed: Q8.5, R13.1
unnamed: Q9.1, R11.2, R12.1
unnamed: Q10.4, R17.1, R18.1
unnamed: Q10.5, R16.1, R19.1
unnamed: Q11.1, R26.2
unnamed: Q12.3, R24.2
unnamed: Q12.6, Q17.1, R30.2
unnamed: Q13.1, Q13.3, Q15.1, R24.1
unnamed: Q13.2, R23.2
unnamed: Q14.1, R25.1
unnamed: Q15.2, R29.2
unnamed: Q15.3, R30.1
unnamed: Q16.1, R31.1
unnamed: Q17.2, R32.2
unnamed: Q17.3, Q18.1, R33.1
unnamed: Q18.2, R35.1
unnamed: Q19.1, R41.2
unnamed: Q19.3, R37.1
unnamed: Q20.1, Q22.3, R38.2
unnamed: Q20.3, Q22.1, R36.1
unnamed: Q23.4, Q23.5, R44.1
unnamed: Q23.6, R41.1, R43.2, R57.1
unnamed: Q24.1, R42.2, R43.1
unnamed: Q24.2, R45.2
unnamed: R39.1, RV3.3
unnamed: R39.2, RV4.1
unnamed: R51.2, RV5.3
unnamed: R54.2, RV6.3
unnamed: RV1.3, RV2.1
V-UNREG: C2.2, C4.2, D1.2, D2.2, DS2.K, DS3.K, J2.1, Q2.2, Q21.2, R2.2, R3.2, R33.2, R35.2

Notes on the sheet:
ERROR AMPLIFIER
POWER INPUT
UNLESS OTHERWISE SPECIFIED
THERMAL CUTOFF
COMPONENT VALUES
E100A
E101A
E102A
R51
180
R54
27k
15k
RV5
500
RV6
20k
10k
R47
LOCAL REGULATOR
VOLTAGE REFERENCE
OUTPUT AMPLIFIER
CURRENT LIMITER
OUTPUT FILTER
FEEDBACK INPUT
METER TRIM
Matching connector: TE Conn 60598-3 Connectors are expensive and optional; holes will take 16g wire as well.
R49
120k
75k
R50
OFF PCB
OFF PCB

Board: 2 copper layers, 100.0 x 75.0 mm, 127 parts (0 on the bottom side), 73 nets.

## KiCad design psu.kicad_pcb

Parts:
C1: 1000u 63V
C2, C6, C8: 47u 63V
C3: 100p
C4: 1n
C5, C7, C9: 4u7
C10: 1nF 1kV
D1, D2, D3, D4, D5, D6, D7, D8, D11, D12: S1D
D9, D10: MMBD4148
DS1: LIM; PartNo PM5RD
DS2: HOT; PartNo PM5RD
DZ1: BZX84B6V2
DZ2: SMCJ30A-E3/9AT
J1: METER
J3: T1A; PartNo 60824-1
J4: T1B; PartNo 60824-1
J5: T1C; PartNo 60824-1
J6: SENSE
J8: OUT+; PartNo 60824-1
J9: OUT-; PartNo 60824-1
Q1, Q4, Q5, Q6: MMBT3906
Q2, Q12, Q14, Q16, Q22: MMBT3904
Q3, Q15: PZT2222A
Q7, Q8, Q11, Q18: PMP4201Y
Q9, Q10, Q13, Q19, Q20, Q21: MMBT2907A
Q17: TIP105
R1, R2, R4, R5, R12, R13, R21, R23, R27, R34: 22k
R3, R24, R30: 33
R6: 18k
R7, R8, R25, R31, R32, R41: 10k
R9, R10: 470
R11, R26, R42: 100k
R14, R15: 22k 0.5%
R16, R17, R18, R19, R20, R22, R28, R29: 1k
R33: * 1/2W
R35, R36: *
R37, R38: 120k 0.5%
R39, R40: 100
R43: 100k; PartNo NTCLE100E3104JB0; MouserPN 594-2381-640-63104
R44: 270
R45: 1Meg
RV1, RV2, RV3, RV4: 10k
RV5, RV6: *
TP1, TP2, TP3, TP4: GND

Connections:
/FB+: Q11.2, Q20.3, R15.2, R37.2
/FB-: D10.3, Q11.1, R14.2, R38.2, R41.1, R42.1
/OUT+: C8.1, D12.2, DZ2.K, J1.1, J8.1, Q18.2, R33.2, R34.1, R36.1, R40.1
/OUT-: C8.2, D11.1, DZ2.A, J1.3, J9.1, Q16.2, Q17.3, R24.1, R34.2, R39.1
CGND: C10.2, R45.2
GND: C2.1, C5.1, C6.1, C7.1, C10.1, D7.1, D8.2, D9.1, Q8.1, Q15.2, Q15.4, R5.1, R11.1, R26.1, R33.1, R35.1, R43.1, R45.1, RV1.1, RV3.1, TP1.1, TP2.1, TP3.1, TP4.1
unnamed: C3.1, Q1.3, R1.1
unnamed: C4.1, Q7.1, R5.2, R6.1
unnamed: C5.2, Q7.2, R8.2
unnamed: C9.1, Q21.3, Q22.1, R43.2, R44.1
unnamed: D1.1, D2.2, J3.1
unnamed: D3.1, D4.2, J5.1
unnamed: D5.1, D6.2
unnamed: D6.1, D7.2
unnamed: D9.3, DZ1.3
unnamed: D10.1, Q11.4, Q11.5, Q12.3
unnamed: D11.2, J6.2, R38.1, R39.2
unnamed: D12.1, J6.1, R37.1, R40.2
unnamed: DS1.A, R32.2
unnamed: DS2.A, R41.2
unnamed: DS2.K, Q21.2
unnamed: DZ1.1, R8.1, R9.1, RV2.2, RV2.3
unnamed: J1.2, RV5.1, RV5.2
unnamed: J1.4, RV6.1, RV6.2
unnamed: Q1.1, Q4.3, R4.1
unnamed: Q2.1, Q3.3, R3.1
unnamed: Q4.1, Q6.3, Q7.3
unnamed: Q5.1, Q5.3, Q6.1, Q7.6
unnamed: Q7.4, Q7.5, R7.1
unnamed: Q8.4, R13.1, R15.1
unnamed: Q8.5, R12.1, R14.1
unnamed: Q9.1, Q9.3, Q10.1, R16.1
unnamed: Q10.3, R17.1
unnamed: Q11.3, R16.2
unnamed: Q11.6, Q13.1, R17.2
unnamed: Q12.1, R9.2, R10.1
unnamed: Q12.2, R18.1
unnamed: Q13.2, R19.2
unnamed: Q13.3, Q14.1, R20.1
unnamed: Q14.2, R22.1
unnamed: Q14.3, Q17.1, R21.2, R23.2
unnamed: Q15.1, Q16.3, R23.1
unnamed: Q15.3, Q16.1, R24.2
unnamed: Q18.4, Q18.5, R25.1
unnamed: Q18.6, R28.2, R31.1
unnamed: Q19.1, R31.2
unnamed: Q19.3, R32.1
unnamed: Q20.1, R28.1, R29.2
unnamed: Q20.2, R30.2
unnamed: Q21.1, Q22.3, R42.2
unnamed: R27.1, RV3.3
unnamed: R27.2, RV4.1
unnamed: R35.2, RV5.3
unnamed: R36.2, RV6.3
unnamed: RV1.3, RV2.1
V+: C1.1, D2.1, D4.1, D5.2, D8.1, Q1.2, Q4.2, Q5.2, Q6.2, Q8.3, Q8.6, Q9.2, Q10.2, Q18.3, Q19.2, R19.1, R21.1, R29.1, R30.1
V-: C4.2, C6.2, C9.2, DS1.K, Q3.2, Q3.4, Q22.2, R4.2, R6.2, R7.2, R10.2, R12.2, R13.2, R18.2, R25.2, R44.2, RV4.2, RV4.3
V-UNREG: C1.2, C2.2, D1.2, D3.2, J4.1, Q2.2, Q17.2, R3.2, R20.2, R22.2

Notes on the sheet:
ERROR AMPLIFIER
POWER INPUT
UNLESS OTHERWISE SPECIFIED
THERMAL CUTOFF
Coupled to Q9
PANEL METER
COMPONENT VALUES
PS-1H
PS-1L
PS-1LL
R35
180
R36
27k
15k
RV5
500
RV6
20k
10k
R33
R47
LOCAL REGULATOR
VOLTAGE REFERENCE
OUTPUT AMPLIFIER
CURRENT LIMITER
OUTPUT FILTER
FEEDBACK INPUT
ESR > 0r5
METER TRIM
Matching connector: TE Conn 60598-3 Connectors are expensive and optional; holes will take 16g wire as well.

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
Board: 2 copper layers, 100.0 x 75.0 mm, 109 parts (0 on the bottom side), 61 nets.

## KiCad design noiseamp/noiseamp.kicad_pcb

Parts:
C1, C2: 22000u 10V
C3, C4, C5, C6: 2200u
C7, C8, C9, C10, C12, C15: 1u
C11: 10n
C13, C14: 100n
C16, C17, C18, C19, C20, C21: 10u
D1, D2, D3, D4: 1N4001
J1, J2, J3, J4, J5: XCONN
J8: OUT-LF
J9: OUT-HF
R1, R2: 150
R3, R4: 470k
R6, R7, R17, R18, R19, R20: 33k
R8: 62
R9: 2k7
R10: 6k2
R11, R12: 22k
R13: 1k5
R14, R15, R21, R22: 10k
R16: 4k7
U1: AD8429ARZ
U2, U3: AD8597ARZ

Connections:
GND: C1.2, C2.1, C8.2, C10.2, C11.2, C16.2, C17.1, C18.2, C19.1, C20.2, C21.1, D1.1, D2.2, D3.2, D4.1, J4.IN, J8.2, J9.2, R3.2, R4.1, R6.2, R7.1, R15.2, R18.2, R20.2, R22.2, U1.6 (REF); also elsewhere on the board
unnamed: C3.1, J1.IN
unnamed: C3.2, C5.2, R3.1
unnamed: C4.1, C6.1, R4.2
unnamed: C4.2, J2.IN
unnamed: C7.1, C9.1, J8.1, R14.1, U2.6 (OUT)
unnamed: C7.2, R10.2, R11.1
unnamed: C8.1, R11.2, R12.1
unnamed: C9.2, R12.2, R13.1
unnamed: C10.1, R13.2, U2.3 (IN+)
unnamed: C11.1, C12.1, R16.2
unnamed: C12.2, C13.1, R17.2
unnamed: C13.2, C14.1, R18.1
unnamed: C14.2, C15.1, R19.2
unnamed: C15.2, R20.1, U3.3 (IN+)
unnamed: J3.IN, R1.1
unnamed: J5.IN, R2.1
unnamed: J9.1, R17.1, R19.1, R21.1, U3.6 (OUT)
unnamed: R8.1, R9.1, U1.2 (RG-)
unnamed: R8.2, R9.2, U1.3 (RG+)
unnamed: R10.1, R16.1, U1.7 (VOUT)
unnamed: R14.2, R15.1, U2.2 (IN-)
unnamed: R21.2, R22.1, U3.2 (IN-)
V+: C1.1, C16.1, C18.1, C20.1, R1.2, U1.8 (+VS), U2.7 (V+), U3.7 (V+)
V-: C2.2, C17.2, C19.2, C21.2, R2.2, U1.5 (-VS), U2.4 (V-), U3.4 (V-)

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
Board: 2 copper layers, 90.0 x 90.0 mm, 58 parts (0 on the bottom side), 27 nets.

Other parts of the board:
J6: NULL; CONN_3-SIL
R5: 33k; R-250mW

Their connections:
GND: J6.2; also elsewhere on the board

## KiCad design REV-A-PCB/psu.kicad_pcb

Board: 2 copper layers, 83.0 x 50.0 mm, 76 parts (0 on the bottom side), 42 nets.

Parts:
C1: 470u 10V; C-ALUM-8mm
C2: 1000u 63V; C-ALUM-16mm
C3, C6: 47u 10V; CAPAE660X570
C4: 1u; CAPC2012X70
C5: 33p 50V; RESC2012X50
C7: 10n; CAPC2012X70
C8: 47u 50V; C-ALUM-6.3mm
D1: 1N4001; DO-41
D2: GBU 100V; D2
D3, D4: MMBD4148; SOT-23
DZ1: BZX84B33; SOT-23
DZ2: BZX84B6V2; SOT-23
DZ3: BZX84C2V4; SOT-23
DZ4: SMP30A; DZ4
J1: T2A; TEST
J2: T2B; TEST
J3: T1A; TEST
J4: T1B; TEST
J5: T1C; TEST
J6: SENSE+; TEST
J7: SENSE-; TEST
J8: OUT+; TEST
J9: OUT-; TEST
MP1, MP2, MP3, MP4: SCREW; SCREW-4-SUPPORTED
Q1, Q2, Q6, Q13: MMBT3904; SOT-23
Q3, Q8: PZT2907A; SOT-223
Q4, Q5: PMP4201Y; SC-70-6
Q7: MMBT2907A; SOT-23
Q9: D45H11; CONN_3-SIL
Q10, Q11, Q14, Q15: MMBT3906; SOT-23
Q12, Q16: PMP5201Y; SC-70-6
R1, R13, R15, R25: 10k; RESC2012X50
R2, R17: 330; RESC2012X50
R3, R4, R10, R20: 2k2; RESC2012X50
R5: 62k 1%; RESC2012X50
R6: 56k 1%; RESC2012X50
R7, R8: 22k 0.5%; RESC2012X50
R9, R12, R26: 1k; RESC2012X50
R11: 22k; RESC2012X50
R14, R28: 12k; RESC2012X50
R16: 100; RESC2012X50
R18: 3k3; RESC2012X50
R19: 820; RESC2012X50
R21: 1R 1/2W; RESC3225X60
R22, R23: 120k 0.5%; RESC2012X50
R24: 120k; RESC2012X50
RV1: 5k; TRIM-R-BOURNS-TC33X-2
RV2, RV4: 10k; CONN_3-SIL
RV3: 2k; TRIM-R-BOURNS-TC33X-2

Connections:
/FB+: Q5.1, R8.2, R22.2, R26.2
/FB-: C5.1, D4.3, Q5.2, Q13.3, R7.2, R23.2
/V+: C1.2, C2.1, C3.1, C4.1, C8.1, D2.4, D3.1, DZ1.3, DZ4.K, J2.1, J8.1, Q4.1, Q4.3, Q4.6, R1.1, R11.1, R13.1, R17.2, R28.1, RV2.1
/V-: C2.2, D2.1, J4.1, Q1.2, Q3.2, Q3.4, Q8.2, Q8.4, Q9.2, R2.2, R15.2
/VBIAS: C6.2, DZ3.1, Q10.1, Q11.1, Q14.1, Q15.2, R17.1
/VCC: C1.1, C6.1, D1.1, DZ3.3, Q7.2, Q16.4, Q16.5, R18.1, R19.1, R25.1
/VEE: Q3.3, Q12.3, Q13.2, R4.2, R5.2, R6.2, R10.2, R12.2, R20.2, R24.2
unnamed: C3.2, DZ2.1, R3.1, RV1.2, RV1.3
unnamed: C4.2, Q4.2, R28.2, RV2.2
unnamed: C5.2, Q7.3, Q8.1, R15.1
unnamed: C7.1, Q12.1, R14.1, RV4.2
unnamed: C7.2, Q9.3, R14.2, R16.1, R21.1, RV3.1, RV4.3
unnamed: C8.2, DZ4.A, J9.1, Q12.2, R21.2
unnamed: D1.2, J1.1
unnamed: D2.2, J3.1
unnamed: D2.3, J5.1
unnamed: D3.3, DZ2.3
unnamed: D4.1, Q5.4, Q5.5, Q6.3
unnamed: DZ1.1, Q2.3, Q3.1
unnamed: J6.1, R22.1
unnamed: J7.1, R23.1, R24.1
unnamed: Q1.1, Q2.2, R2.1
unnamed: Q1.3, Q2.1, R1.2
unnamed: Q4.4, R6.1, R8.1
unnamed: Q4.5, R5.1, R7.1
unnamed: Q5.6, R9.2
unnamed: Q6.1, R10.1, R11.2
unnamed: Q6.2, R12.1
unnamed: Q8.3, Q9.1, R16.2
unnamed: Q10.2, R18.2
unnamed: Q10.3, RV3.3
unnamed: Q11.2, R19.2
unnamed: Q11.3, Q12.4, Q12.5
unnamed: Q12.6, Q13.1, R20.1
unnamed: Q14.2, R25.2
unnamed: Q14.3, Q15.1, R13.2
unnamed: Q15.3, R26.1
unnamed: Q5.3, Q16.1, Q16.2, Q16.3
unnamed: Q7.1, Q16.6, R9.1
unnamed: R3.2, R4.1
unnamed: RV1.1, RV2.3
unnamed: RV3.2, RV4.1

## Commit log

2014-01-24 Finally put this in a git repo...
2014-01-24 Changed local regulator circuit, added github readme
2014-03-18 Rev C in progress
2014-03-18 Create gh-pages branch via GitHub
2014-03-18 Added PCB render
2014-03-18 Added PCB render?
    Will this work?
2014-03-18 Added beginning of simulation
2014-03-23 Few BOM-related changes
2014-03-23 Moved noise amplifier out of project
2014-03-23 Removed revision A PCB
2014-03-23 Moved main KiCad project into Proj-Main/
2014-03-23 Created separate wiring diagram
2014-05-04 Added R46, R47
2014-05-04 Added power LED DS3
2014-05-04 Added regulator bootstrap resistor R48
2014-05-04 Adjusted regulator feedback resistors
2014-05-04 Improved design of current source
2014-05-04 Added new thermal cutoff
2014-05-04 Added current mirror degeneration resistors R54, R55
2014-05-04 Renamed voltage rails (V+ and V- now +2 and -12)
2014-05-04 Updated LED bias points
2014-05-04 Rearranged schematic
2014-05-04 Reannotated schematic
2014-05-04 PCB tweaks
2014-05-05 More PCB tweaks
2014-05-05 PCB and rendering tweaks
2014-05-05 Zone under Q3 was assigned to the wrong net
2014-05-05 Frequency compensation
2014-05-05 Fixed another disconnected zone
2014-05-05 Straightened crooked trace
2014-05-07 Added guard traces, fixed overlapping components
2014-05-07 Corrected missing connection
2014-05-14 Removed thermals from high-current pads
2014-05-15 Some PCB tweaks
2014-05-16 PCB REV A
